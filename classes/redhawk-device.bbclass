
inherit redhawk-base

EXTRA_OECONF += "--libdir=${OSSIEHOME}/lib --includedir=${OSSIEHOME}/include"

